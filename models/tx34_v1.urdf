Commit message: URDF export path resolution; README note on working directory

File: models/tx34_v1.urdf (robot description, URDF)
Before this commit: robot TX34_NOVA, 27 links, 26 joints
Joints:
- joint base_pelvis: type fixed -> floating
